Properties of the parts of a building model (IFC4), part 3 of 3

# IfcBuildingElementProxy: 5 мини.stp[957]
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 мини.stp[958]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 мини.stp[959]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 мини.stp[95]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 мини.stp[960]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 мини.stp[961]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 мини.stp[962]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 мини.stp[963]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 мини.stp[964]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 мини.stp[965]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 мини.stp[966]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 мини.stp[967]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 мини.stp[968]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 мини.stp[969]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 мини.stp[96]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 мини.stp[970]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 мини.stp[971]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 мини.stp[972]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 мини.stp[973]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 мини.stp[974]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 мини.stp[975]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 мини.stp[976]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 мини.stp[977]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 мини.stp[978]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 мини.stp[979]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 мини.stp[97]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 мини.stp[980]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 мини.stp[981]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 мини.stp[982]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 мини.stp[983]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 мини.stp[984]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 мини.stp[985]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 мини.stp[986]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 мини.stp[987]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 мини.stp[988]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 мини.stp[989]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 мини.stp[98]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 мини.stp[990]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 мини.stp[991]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 мини.stp[992]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 мини.stp[993]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 мини.stp[994]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 мини.stp[995]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 мини.stp[996]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 мини.stp[997]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 мини.stp[998]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 мини.stp[999]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 мини.stp[99]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 5 мини.stp[9]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: SS.SEMA.2400 - Сима-профиль (66)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: SS.SEMA.2400 - Сима-профиль — обрезан 1600 (22)
In: Default Storey
PredefinedType: ELEMENT; Material: 0
